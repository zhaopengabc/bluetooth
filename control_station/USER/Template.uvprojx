# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FB1010_HW5000_9600_15 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,USART_USART2_TRANS,D026_HW200,XYB_CXY,FB1010
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\HARDWARE;..\HARDWARE\APPFLASH;..\HARDWARE\APPUART;..\HARDWARE\APPSPI;..\HARDWARE\APPLCD;..\HARDWARE\APPNET;..\HARDWARE\SDdriver;..\HARDWARE\APPCAN;..\HARDWARE\W5500\Internet;..\HARDWARE\W5500\W5500;..\HARDWARE\PROALY;..\HARDWARE\PROALY\PluginClib;..\HARDWARE\PROALY\PluginHlib;..\HARDWARE\WileLess;..\HARDWARE\APPATcmd;..\HARDWARE\BTfunction
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/: buzzer.c key.c Voice.c rtc.c frame.c SendToServer.c RecieveFromServer.c SendToServerDataType.c ServerAction.c mainpower.c ProtocolBoard.c bsp_FB1000Y.c wdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_can.c stm32f10x_adc.c
  group UCOSIII-BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group APPSPI
    ../HARDWARE/APPSPI/: MsgSPIProcessDrv.c MsgSPIProcessAppExt.h MsgSPIProcessCfgExt.h MsgSPIProcessDrv.h MsgSPIProcessHWExt.h
  group APPUART
    ../HARDWARE/APPUART/: UsartMsgProcessAppExt.h UsartMsgProcessCfgExt.h UsartMsgProcessDrv.c UsartMsgProcessDrv.h UsartMsgProcessHWExt.h
  group APPNET
    ../HARDWARE/APPNET/: net.c usart2.c usart3.c
  group APPFLASH
    ../HARDWARE/APPFLASH/: spi_flash.c w25q16.c
  group APPLCD
    ../HARDWARE/APPLCD/: lcd.c uart5.c
  group APPCAN
    ../HARDWARE/APPCAN/: MsgCANProcessDrv.c MsgCANProcessAppExt.h MsgCANProcessCfgExt.h MsgCANProcessDrv.h MsgCANProcessHWExt.h
  group W5500
    ../HARDWARE/W5500/W5500/: socket.c utility.c w5500.c w5500_conf.c w5500_Ctl.c
    ../HARDWARE/W5500/Internet/: dhcp.c dns.c tcp_demo.c
  group PRPALY
    ../HARDWARE/PROALY/PluginHlib/: choicedevice.c DeviceCommon.c ReceiveDataBuffer.c choicedevice.h
    ../HARDWARE/PROALY/: app.c
    ../HARDWARE/APPCAN/: CAN1ProtocolParsing.c
  group MClib
    ../HARDWARE/PROALY/PluginClib/: D026_HW200.c
  group ReadMe
    ../: readme.txt
  group WileLess
    ../HARDWARE/WileLess/: bc95.c
  group APPATcmd
    ../HARDWARE/APPATcmd/: PrinterATcmd.c PrinterATrev.c
  group BTfunction
    ../HARDWARE/BTfunction/: BTfunction.c
